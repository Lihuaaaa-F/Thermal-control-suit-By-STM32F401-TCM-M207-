/* fuzz_m207.c — H11 parser 万条模糊测试（确定性种子，可复现）
 * 随机字节流喂 m207_lineasm_feed → m207_parse_line，断言：
 *   1) 不崩溃（缓冲边界安全）；2) 解析成功时输出字段受约束（module∈{0,1,2}、
 *   param 非空且 ≤15、行号 ≤ M207_LINE_MAX）。
 */
#include <stdio.h>
#include <string.h>
#include "m207.h"

static unsigned int s_seed = 0x5EED2026;
static unsigned int rnd(void)
{
    s_seed = s_seed * 1103515245u + 12345u;
    return (s_seed >> 16) & 0x7FFF;
}

int main(void)
{
    const int N = 10000;
    m207_lineasm_t la;
    m207_lineasm_reset(&la);
    char line[M207_LINE_MAX + 1];
    int parsed = 0, fed = 0;

    const char *tmpl[] = {
        "TC1:TCACTTEMP?
", "TC2:TCACTTEMP=25.5
", "TC1:TCADJTEMP=30.0
",
        "TC2:TCSW=1
", "TC1:PIDKP=1.500
", "tc2:tcadjtemp=15.5
",
        "TC1:XXX?=
", "TC9:Y=1
", ":=
", "TC1:=
",
    };
    for (int i = 0; i < N; i++) {
        unsigned int r = rnd();
        /* 30% 结构化正例（含变异）+70% 随机字节：保证解析路径被真实覆盖 */
        if (r % 10 < 3) {
            const char *t = tmpl[rnd() % 10];
            for (const char *q = t; *q; q++) {
                uint8_t b = (uint8_t)*q;
                if (rnd() % 20 == 0) b = (uint8_t)(rnd() & 0xFF);   // 变异
                fed++;
                if (m207_lineasm_feed(&la, b, line, sizeof(line))) {
                    m207_reply_t out;
                    memset(&out, 0xAA, sizeof(out));
                    if (m207_parse_line(line, &out)) {
                        parsed++;
                        if (out.module > 2) { printf("FAIL: module=%u
", out.module); return 1; }
                        if (out.param[0] == '' || strlen(out.param) >= sizeof(out.param)) {
                            printf("FAIL: param bounds
"); return 1;
                        }
                    }
                }
            }
            if (i % 97 == 0) m207_lineasm_reset(&la);
            continue;
        }
        uint8_t b;
        switch (r % 8) {
        case 0: b = (uint8_t)'T'; break;
        case 1: b = (uint8_t)'C'; break;
        case 2: b = (uint8_t)('1' + (r >> 3) % 3); break;      /* 1/2/3 */
        case 3: b = (uint8_t)":"[0]; break;
        case 4: b = (uint8_t)((r >> 5) % 2 ? '=' : '?'); break;
        case 5: b = (uint8_t)('0' + (r >> 7) % 10); break;
        case 6: b = (uint8_t)(r >> 9); break;                   /* 任意字节 */
        default: b = (uint8_t)("\r\n. -abcXYZ"[ (r >> 9) % 12 ]); break;
        }
        fed++;
        if (m207_lineasm_feed(&la, b, line, sizeof(line))) {
            if (la.len != 0) { printf("FAIL: lineasm not reset\n"); return 1; }
            m207_reply_t out;
            memset(&out, 0xAA, sizeof(out));
            if (m207_parse_line(line, &out)) {
                parsed++;
                if (out.module > 2) { printf("FAIL: module=%u\n", out.module); return 1; }
                if (out.param[0] == '\0' || strlen(out.param) >= sizeof(out.param)) {
                    printf("FAIL: param bounds\n"); return 1;
                }
                if (strlen(line) > M207_LINE_MAX) { printf("FAIL: line bounds\n"); return 1; }
            }
        }
        /* 周期性复位行拼装，覆盖半行状态 */
        if (i % 977 == 0) m207_lineasm_reset(&la);
    }
    printf("fuzz_m207: fed=%d parsed=%d (seed 0x5EED2026) — no crash, invariants hold\n",
           fed, parsed);
    return 0;
}
